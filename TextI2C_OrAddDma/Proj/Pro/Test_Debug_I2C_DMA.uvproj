# Keil uVision project Test_Debug_I2C_DMA.uvproj, settings and files
target I2C_Master_Send (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Test_Debug_I2C_DMA
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\..\ST_libs\CMSI\inc;..\..\ST_libs\FWlib\inc;..\libSource;..\Source\inc;..\BspSource\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../libSource/: stm32f4xx_it.c main.c
  group Bsp_src
    ../BspSource/src/: I2C_MasterComInit.c I2C_SlaveComInit.c
  group StartUp
    ../../ST_libs/CMSI/: startup_stm32f4xx.s
    ../libSource/: system_stm32f4xx.c
  group FwLib
    ../../ST_libs/FWlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
target I2C_Slave_Recerve (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: Test_Debug_I2C_DMA
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,I2C_Salve,
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
